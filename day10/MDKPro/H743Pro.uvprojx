# Keil uVision project H743Pro.uvprojx, settings and files
target STM32H743VIT (6110000::V6.11::.\ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H743Pro
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: HSE_VALUE = 8000000,BOARD_TURING_PURE = 1
  c include: ..\SL_RTE\RTE_APP;..\SL_RTE\RTE_Module;..\SL_RTE\RTE_Board\TuringBoard;..\SL_RTE\RTE_BSP\General_H7;..\SL_RTE\RTE_Config;..\SL_RTE\RTE_GUI;..\SL_RTE\RTE_Utils\RAK439;..\SL_RTE\RTE_Utils\FatFS;..\SL_RTE\RTE_MV;..\Thread_All;..\APP_GUI;..\APP_SM
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\H743Pro.sct
  group UserMain
    ../UserMain/: device_interupt.c main.c
  group STM32CubeMX:Generate Sources
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Src/: gpio.c usart.c dma.c spi.c sdmmc.c bsp_driver_sd.c fatfs.c fatfs_platform.c sd_diskio.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Inc/: stm32h7xx_it.h
  group RTE_Core
    ../SL_RTE/RTE_APP/: RTE_KVDB.c RTE_LOG.c RTE_MATH.c RTE_MEM.c RTE_RingQuene.c RTE_RoundRobin.c RTE_Shell.c RTE_StateMachine.c RTE_UStdout.c RTE_UString.c RTE_Vec.c RTE_LinkList.c RTE_Array.c
  group RTE_BSP
    ../SL_RTE/RTE_BSP/General_H7/: BSP_Led.c BSP_Systick.c
  group RTE_Module
    ../SL_RTE/RTE_Module/: File_Module.c File_Shell_Module.c GUI_Shell_Module.c
  group RTE_Port
    ../SL_RTE/RTE_Port/: RTE_Port.c
  group RTE_Board
    ../SL_RTE/RTE_Board/TuringBoard/: Board_HALCallback.c Board_Interupt.c Board_MSPInit.c Board_Initial.c Board_Uart.c Board_SPI.c Board_LCD.c Board_WIFI.c Board_SDCard.c Board_FatFS.c
  group RTE_Utils/WIFI
    ../SL_RTE/RTE_Utils/RAK439/: rak_wifi_os_port.c rak_wifi_ap_sta.c rak_wifi_os_ARM_CM4F_V1.0.7.lib
  group RTE_Utils/LittleFS
    ../SL_RTE/RTE_Utils/LittleFS/: lfs.c lfs_util.c
  group RTE_Utils/FATFS
    ../SL_RTE/RTE_Utils/FatFs/: diskio.c ff.c ff_gen_drv.c
    ../SL_RTE/RTE_Utils/FatFs/option/: cc936.c syscall.c
  group RTE_MV/Core
    ../SL_RTE/RTE_MV/MV_Core/: MV_Image.c MV_Color.c MV_Haar.c MV_Integral.c MV_Integral_MW.c MV_Point.c MV_Rectangle.c
  group RTE_MV/Support
    ../SL_RTE/RTE_MV/MV_Support/: MV_BMP.c MV_File.c MV_FrameBuffer.c MV_PPM.c MV_TXT.c
  group RTE_MV/Table
    ../SL_RTE/RTE_MV/MV_Table/: rgb2rgb_tab.c lab_tab.c xyz_tab.c yuv_tab.c
  group GUI_Core
    ../SL_RTE/RTE_GUI/GUI_Core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
  group GUI_Misc
    ../SL_RTE/RTE_GUI/GUI_Misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_fs.c lv_txt.c lv_ufs.c
  group GUI_Hal
    ../SL_RTE/RTE_GUI/GUI_Hal/: lv_hal_disp.c lv_hal_indev.c
  group GUI_Font
    ../SL_RTE/RTE_GUI/GUI_Font/: lv_font.c lv_font_builtin.c lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_monospace_8.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group GUI_Draw
    ../SL_RTE/RTE_GUI/GUI_Draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rbasic.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vbasic.c
  group GUI_Objx
    ../SL_RTE/RTE_GUI/GUI_Objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
  group GUI_Theme
    ../SL_RTE/RTE_GUI/GUI_Theme/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_zen.c
  group GUI_Manage
    ../SL_RTE/RTE_GUI/: GUI_Manage.c GUI_ObjTable.c
  group RTE_Config
    ../SL_RTE/RTE_Board/TuringBoard/: Board_Config.h
    ../SL_RTE/RTE_Config/: RTE_Config.h
    ../SL_RTE/RTE_GUI/: GUI_Config.h GUI_Port.h
  group APP_Thread
    ../Thread_All/: Thread_System.c Thread_GUI.c Thread_WIFI.c
  group APP_GUI
    ../APP_GUI/: GUI_TouchCorrect.c GUI_OverAll.c GUI_Filebrowser.c
  group APP_SM
    ../APP_SM/: WIFI_SM.c
  group APP_Data
    ../APP_Data/: img_cursor.c img_file.c
target STM32H743VITCubeMX (6110000::V6.11::.\ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: as above
  output: H743Pro
  c flags: as above
  c define: HSE_VALUE = 8000000,BOARD_TURING_PURE= 0,RTE_USE_OS=0,RTE_USE_GUI=0,RTE_Compiler_IO_STDOUT_User
  c include: ..\SL_RTE\RTE_APP;..\SL_RTE\RTE_Board\TuringBoard;..\SL_RTE\RTE_BSP\General_H7;..\SL_RTE\RTE_Config;..\Thread_All;..\SL_RTE\RTE_GUI;..\SL_RTE\RTE_Utils\FatFs
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\H743Pro.sct
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SD 1.3.0, Device:STM32Cube HAL:SPI 1.3.0, Device:STM32Cube HAL:TIM 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:Startup 1.2.0

# Keil uVision project H743Pro.uvprojx, settings and files
target STM32H743VIT (6110000::V6.11::.\ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H743Pro
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Objects\H743Pro.sct
  group STM32CubeMX:Generate Sources
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Src/: gpio.c stm32h7xx_hal_timebase_tim.c usart.c dma.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743VITx/STCubeGenerated/Inc/: stm32h7xx_it.h
software components: CMSIS:CORE 5.1.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:TIM 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:Startup 1.2.0
